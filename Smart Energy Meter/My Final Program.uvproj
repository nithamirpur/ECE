# Keil uVision project My Final Program.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: My Final Program +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: LCD.h delay.h main.c lcd.c Keyboard.c delay.c keyboard.h gsm.c gsm.h
